# Repository robinbowes/PrincetonReverbUpdate

File README.md:

# Yet another modded Princeton Reverb

I started off with a Modulus Amplification Princetown Reverb kit. That should have been it. But I wanted to do some of the mods people do, as well as incorporate some of the things Merlin Blencowe suggests in his books.

Initially, I thought I could get away with altering the supplied turret board. Alas, that was just taking up too much thinking time. It was far easier to just draw up a PCB.

Things I've done:

- moved the reverb to its own node
- moved the LFO to its own spur
- used an LED to bias the LFO
- added a large stopper to the PI grid
- reduced the PI coupling caps going to the 6V6s (I could reduce further, but we'll see)
- adopted a multi-star grounding scheme using ground planes for each node, that daisy chain from the reservoir cap to the input
- a single earth <-> signal ground connection near the input
- tried to make the off-board connections short
- it's all on one board! No need for a bias board.

## Things that could do with improving

Should anyone want to take this and make it better, I'd add another mounting hole somewhere in the middle. 

## Licence

This project is licensed under **Creative Commons Attribution-NonCommercial-ShareAlike 4.0 International (CC BY-NC-SA 4.0)**.

© 2026 Tristan Collins

### You are free to:
- **Use and study** the design for personal, educational, or research purposes
- **Adapt** — remix, modify, or build upon it
- **Share** — redistribute in any medium or format

### Under these conditions:
- **Attribution** — credit the original, link to the licence, note any changes
- **NonCommercial** — may not be used for commercial purposes without permission
- **ShareAlike** — adaptations must be released under the same licence

### Commercial use
If you want to manufacture or sell PCBs, kits, or assemblies based on this design, you need a commercial licence. Get in touch: **hard.zoo4108@fastmail.com**

Full licence text: [LICENSE](./LICENSE)

## KiCad design PrincetonReverbUpdate.kicad_pcb

Board: 2 copper layers, 275.0 x 55.0 mm, 119 parts (0 on the bottom side), 52 nets.

Parts:
C1, C2, C7, C9, C12, C24, C29: 22u 50V; CP_Radial_D5.0mm_P2.00mm
C3: 250p 500V; C_Disc_D10.5mm_W5.0mm_P7.50mm_TC
C4, C22: 100n 630V; C_Axial_L22.0mm_D10.5mm_P27.50mm_Horizontal_TC
C5: 47n 630V; C_Axial_L17.0mm_D6.5mm_P20.00mm_Horizontal_TC
C6: 470p 500V; C_Disc_D7.5mm_W5.0mm_P7.50mm_TC
C8, C14, C19: 22n 630V; C_Axial_L17.0mm_D6.5mm_P20.00mm_Horizontal_TC
C10: 10p 500V; C_Disc_D10.5mm_W5.0mm_P7.50mm_TC
C11: 3.3n 630V; C_Rect_L16.5mm_W6.0mm_P15.00mm_MKT_TC
C13: 10n 630V; C_Rect_L11.0mm_W5.1mm_P10.00mm_MKT_TC
C15, C17: 22n 630V; C_Rect_L11.0mm_W5.1mm_P10.00mm_MKT_TC
C18, C23, C25: 22u 450V; CP_Radial_D12.5mm_P5.00mm
C20, C21: 47n 630V; C_Axial_L19.0mm_D7.5mm_P25.00mm_Horizontal_TC
C27: 100p; C_Disc_D10.5mm_W5.0mm_P7.50mm_TC
D1: UF4007; D_DO-41_SOD81_P7.62mm_Horizontal
D2: Red; LED_D5.0mm
H1: 4mm Hole; MountingHole_4.3mm_M4_TC
H2: 4mm HolePad; MountingHole_4.3mm_M4_ISO7380_Pad
JP4: AB-C; SolderJumper-2_P1_3mm_Bridged_Pad1_0x1_5mm_TC_Via
JP5: C-D; SolderJumper-2_P1_3mm_Bridged_Pad1_0x1_5mm_TC_Via
JP6: D-E; SolderJumper-2_P1_3mm_Bridged_Pad1_0x1_5mm_TC_Via
R4, R5, R11, R14, R18: 1.5k; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R6, R21, R23, R24, R31: 1Meg; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R7, R8, R13, R16, R20, R39: 100k; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R9, R40, R41: 10k 3W; R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal_TC
R10: 6.8k; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R12, R29, R33, R34: 220k; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R15: 3.3M; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R17: 470k; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R19: 47r; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R22: 2.7k; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R26: 1k; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R27, R30: 56k; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R28: 10k 1W; R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal_TC
R35: 10k; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R37: 100k 1W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
R42: 1k 3W; R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal_TC
R46: 220k 3W; R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal_TC
R48: 1r 1%; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC
RV7: 22k Lin; Potentiometer_Bourns_3296W_Vertical
TP1: BiasTP; TestPoint_Keystone_5005-5009_Compact
TP2: GND; TestPoint_Keystone_5005-5009_Compact
W1: FETB+; SolderWire_TC
W2: 1-1; SolderWire_TC
W3: TrebTop; SolderWire_TC
W4: 1-6; SolderWire_TC
W5: 3-1; SolderWire_TC
W6: 4-1; SolderWire_TC
W7: 6V6A; SolderWire_TC
W8: 3-2; SolderWire_TC
W9: 4-2stop; SolderWire_TC
W10: 6V6Cathode; SolderWire_TC
W11: BassTop; SolderWire_TC
W12: Spk GND; SolderWire_TC
W13: 1-3; SolderWire_TC
W14: BassBot; SolderWire_TC
W15: 1-8; SolderWire_TC
W16: 3-3; SolderWire_TC
W17: 4-3; SolderWire_TC
W18: 6V6B; SolderWire_TC
W19: NFBin; SolderWire_TC
W20: GNDFromInputJack; SolderWire_TC
W21: ToRevTX; SolderWire_TC
W22: RevProtectorGND; SolderWire_TC
W23: IntWiper; SolderWire_TC
W24: 3-6; SolderWire_TC
W25: 4-6; SolderWire_TC
W26: IntTop; SolderWire_TC
W27: IntBot; SolderWire_TC
W28: 2-2; SolderWire_TC
W29: 3-7; SolderWire_TC
W30: RevPotTop; SolderWire_TC
W31: SpeedPotTop; SolderWire_TC
W32: 4-7; SolderWire_TC
W33: RevPotWiper; SolderWire_TC
W34: 2-8; SolderWire_TC
W35: 3-8; SolderWire_TC
W36: RevPotBot; SolderWire_TC
W37: SpeedPotBot; SolderWire_TC
W38: 4-8; SolderWire_TC
W39: ACBiasIn; SolderWire_TC
W40: BToCapCanB; SolderWire_TC
W41: AToCapCanA; SolderWire_TC
W42: VibPedGND; SolderWire_TC
W43: RevPedalGND; SolderWire_TC
W44: GNDToCapCan; SolderWire_TC
W45: A'ToCapCanC; SolderWire_TC
W46: VibPedSig; SolderWire_TC

Connections:
/BiasTP: R48.1, TP1.1 (1_1), W10.1 (1_1)
/Rvbgrid: C6.1, R6.2, W28.1 (1_1)
A: R28.1, R42.2, R46.2, W41.1 (1_1)
A': R28.2, R29.2, W45.1 (1_1)
B: R41.2, R42.1, W40.1 (1_1)
Bias: R33.2, R34.2, W23.1 (1_1)
C: C18.1, R40.2, R41.1, W21.1 (1_1)
Chassis: C1.2, C7.2, C25.2, H2.1 (1_1), JP6.2 (B), R5.2, R10.2, R11.2, W20.1 (1_1)
D: C23.1, C27.2, R9.2, R16.1, R30.1, R39.1, R40.1
E: C25.1, R7.2, R9.1, R13.2, W1.1 (1_1)
FromReverb: C10.2, R15.2, R17.2, W8.1 (1_1)
GNDA: C19.2, C24.1, C29.1, D2.1 (K), JP4.1 (A), R20.1, R21.2, R35.2, R46.1, R48.2, TP2.1 (1_1), W42.1 (1_1), W44.1 (1_1)
GNDC: C2.2, C18.2, JP4.2 (B), JP5.1 (A), R4.1, R6.1
GNDD: C9.2, C23.2, JP5.2 (B), JP6.1 (A), R12.1, R14.1, R19.2, R27.1, W12.1 (1_1), W22.1 (1_1), W36.1 (1_1), W43.1 (1_1)
NFB: R22.2, W19.1 (1_1)
unnamed: C1.1, R5.1, W13.1 (1_1)
unnamed: C2.1, R4.2, W34.1 (1_1)
unnamed: C3.1, R7.1, R8.1, W2.1 (1_1)
unnamed: C3.2, W3.1 (1_1)
unnamed: C4.1, C5.1, R8.2
unnamed: C4.2, W11.1 (1_1)
unnamed: C5.2, R10.1, W14.1 (1_1)
unnamed: C7.1, R11.1, W15.1 (1_1)
unnamed: C8.1, R13.1, W4.1 (1_1)
unnamed: C9.1, R14.2, W35.1 (1_1)
unnamed: C11.1, C27.1, R16.2, W24.1 (1_1)
unnamed: C11.2, W30.1 (1_1)
unnamed: C12.1, R18.1, R19.1, R22.1
unnamed: C12.2, R18.2, W16.1 (1_1)
unnamed: C13.2, R21.1, W32.1 (1_1)
unnamed: C14.1, R23.1, W9.1 (1_1)
unnamed: C14.2, R39.2, W5.1 (1_1)
unnamed: C15.1, C17.2, W31.1 (1_1)
unnamed: C17.1, R29.1, R31.2, W25.1 (1_1)
unnamed: C19.1, C22.1, R31.1
unnamed: C20.1, R34.1, W18.1 (1_1)
unnamed: C20.2, R26.2, W17.1 (1_1)
unnamed: C21.1, R33.1, W7.1 (1_1)
unnamed: C21.2, R30.2, W6.1 (1_1)
unnamed: C22.2, W26.1 (1_1)
unnamed: C29.2, RV7.2, W27.1 (1_1)
unnamed: C24.2, D1.2 (A), RV7.3
unnamed: D1.1 (K), R37.2
unnamed: D2.2 (A), R24.1, W38.1 (1_1)
unnamed: R17.1, W33.1 (1_1)
unnamed: R20.2, W37.1 (1_1)
unnamed: R23.2, R26.1, R27.2
unnamed: R35.1, RV7.1
unnamed: R37.1, W39.1 (1_1)
ReverbPedal: R12.2, W29.1 (1_1)
ToReverb: C6.2, C8.2, C10.1, R15.1
VibPedal: C13.1, C15.2, R24.2, W46.1 (1_1)

File gerbers/PCBWay_bom.csv:

Designator,Quantity,Value,Footprint,Package,MPN,DNP,Mount_Type,Description,Sim.Device,Sim.Pins,Sim.Pin
"C1, C12, C2, C24, C29, C7, C9",7,22u 50V,CP_Radial_D5.0mm_P2.00mm,,,,tht,"[C7,C9]Unpolarized capacitor; [C24,C29]Polarized capacitor",,,
C10,1,10p 500V,C_Disc_D10.5mm_W5.0mm_P7.50mm_TC,,,,tht,Unpolarized capacitor,,,
C11,1,3.3n 630V,C_Rect_L16.5mm_W6.0mm_P15.00mm_MKT_TC,,,,tht,Unpolarized capacitor,,,
C13,1,10n 630V,C_Rect_L11.0mm_W5.1mm_P10.00mm_MKT_TC,,,,tht,Unpolarized capacitor,,,
"C14, C19, C8",3,22n 630V,C_Axial_L17.0mm_D6.5mm_P20.00mm_Horizontal_TC,,,,tht,Unpolarized capacitor,,,
"C15, C17",2,22n 630V,C_Rect_L11.0mm_W5.1mm_P10.00mm_MKT_TC,,,,tht,Unpolarized capacitor,,,
"C18, C23, C25",3,22u 450V,CP_Radial_D12.5mm_P5.00mm,,,,tht,Polarized capacitor,,,
"C20, C21",2,47n 630V,C_Axial_L19.0mm_D7.5mm_P25.00mm_Horizontal_TC,,,,tht,Unpolarized capacitor,,,
"C22, C4",2,100n 630V,C_Axial_L22.0mm_D10.5mm_P27.50mm_Horizontal_TC,,,,tht,Unpolarized capacitor,,,
C27,1,100p,C_Disc_D10.5mm_W5.0mm_P7.50mm_TC,,,,tht,Unpolarized capacitor,,,
C3,1,250p 500V,C_Disc_D10.5mm_W5.0mm_P7.50mm_TC,,,,tht,Unpolarized capacitor,,,
C5,1,47n 630V,C_Axial_L17.0mm_D6.5mm_P20.00mm_Horizontal_TC,,,,tht,Unpolarized capacitor,,,
C6,1,470p 500V,C_Disc_D7.5mm_W5.0mm_P7.50mm_TC,,,,tht,Unpolarized capacitor,,,
D1,1,UF4007,D_DO-41_SOD81_P7.62mm_Horizontal,,,,tht,Diode,D,1=K 2=A,
D2,1,Red,LED_D5.0mm,,,,tht,"Light emitting diode, small symbol",,,1=K 2=A
R10,1,6.8k,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
"R11, R14, R18, R4, R5",5,1.5k,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
"R12, R29, R33, R34",4,220k,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
"R13, R16, R20, R39, R7, R8",6,100k,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
R15,1,3.3M,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
R17,1,470k,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
R19,1,47r,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
"R21, R23, R24, R31, R6",5,1Meg,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
R22,1,2.7k,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
R26,1,1k,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
"R27, R30",2,56k,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
R28,1,10k 1W,R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal_TC,,,,tht,Resistor,,,
R35,1,10k,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
R37,1,100k 1W,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
"R40, R41, R9",3,10k 3W,R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal_TC,,,,tht,Resistor,,,
R42,1,1k 3W,R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal_TC,,,,tht,Resistor,,,
R46,1,220k 3W,R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal_TC,,,,tht,Resistor,,,
R48,1,1r 1%,R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal_TC,,,,tht,Resistor,,,
RV7,1,22k Lin,Potentiometer_Bourns_3296W_Vertical,,,,tht,Potentiometer,,,
TP1,1,BiasTP,TestPoint_Keystone_5005-5009_Compact,,,,tht,test point,,,
TP2,1,GND,TestPoint_Keystone_5005-5009_Compact,,,,tht,test point,,,

## Commit log

2026-02-16 remove balance control
2026-02-16 Update schematic PDF [skip ci]
2026-04-03 bump mods branch to kiCad 10
2026-04-03 adding Wx symbols for off-board wiring
2026-04-03 refine schematic
2026-04-03 initial footprint assignment
2026-04-03 Add mods-pcb branch to workflow triggers
2026-04-03 Update workflow to generate PCB render and PDF
2026-04-03 Change PCB output to use image instead of render
    Updated PCB output configuration in kicad-pdf workflow.
2026-04-03 Update schematic PDF and PCB render [skip ci]
2026-04-03 Increasing pcb image quality
2026-04-04 more layout
2026-04-04 fix action yaml
2026-04-04 layout changes
2026-04-04 trying 300 dpi
2026-04-04 testing render options
2026-04-05 more error fixing
2026-04-06 layout, scheme tweak, addlayout image examples
2026-04-08 major layout changes and scheme tweaks
2026-04-08 hide pin numbers
2026-04-09 simplify scheme, tweak footprints
2026-04-09 more layout and footprint alterations
2026-04-09 fix scheme error
2026-04-10 more layout iterations
2026-04-11 place mounting holes
2026-04-11 initial routing attempt, netclasses
2026-04-12 more layout, zones, footprints
2026-04-12 footprint updates, layout updates
2026-04-13 adding DIYLC convertor, and Robinette Layout
2026-04-13 Fixes, added DIYLC files
2026-04-13 updated DIYLC layout
2026-04-14 Taking a commit in case I need to revert ahead of trying to sqeeze the board smaller.
2026-04-14 board resizing, improved layouts
2026-04-14 rename valve connections
2026-04-14 Close to fab
2026-04-14 files for fabrication
2026-04-15 add SVG layup
2026-04-15 Add licence and readme [skip ci]
2026-04-15 Fix input wiring
2026-04-15 Fix input layout in DIYLC[skip ci]
2026-04-16 fix rectifier, update readme, prep bom
2026-04-16 Typo on schematic
2026-04-17 add part ratings, tweak values
2026-04-17 updating BoM
2026-04-22 update layout [skip-ci]
2026-04-24 add thump diode, scheme tweaks
2026-04-24 update workflow
2026-04-24 Rename fab-updates to fab_updates in workflow
2026-04-25 udpate layout [skip ci]
2026-04-28 as built
2026-04-29 version built
2026-06-11 add note to schematic on jack grounding
2026-06-11 replace Arial -> Default fonts
2026-06-24 Add 'updates' directory to workflow paths

Notices in the files:
README.md:
License: CC BY-NC-SA 4.0
